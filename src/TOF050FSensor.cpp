#include "TOF050FSensor.h"

const uint8_t TOF050FSensor::crc16mTableHi[] = {
  0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81,
  0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0,
  0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01,
  0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
  0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81,
  0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0,
  0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01,
  0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
  0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81,
  0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0,
  0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01,
  0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
  0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81,
  0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0,
  0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01,
  0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
  0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81,
  0x40
};

const uint8_t TOF050FSensor::crc16mTableLo[] = {
  0x00, 0xC0, 0xC1, 0x01, 0xC3, 0x03, 0x02, 0xC2, 0xC6, 0x06, 0x07, 0xC7, 0x05, 0xC5, 0xC4,
  0x04, 0xCC, 0x0C, 0x0D, 0xCD, 0x0F, 0xCF, 0xCE, 0x0E, 0x0A, 0xCA, 0xCB, 0x0B, 0xC9, 0x09,
  0x08, 0xC8, 0xD8, 0x18, 0x19, 0xD9, 0x1B, 0xDB, 0xDA, 0x1A, 0x1E, 0xDE, 0xDF, 0x1F, 0xDD,
  0x1D, 0x1C, 0xDC, 0x14, 0xD4, 0xD5, 0x15, 0xD7, 0x17, 0x16, 0xD6, 0xD2, 0x12, 0x13, 0xD3,
  0x11, 0xD1, 0xD0, 0x10, 0xF0, 0x30, 0x31, 0xF1, 0x33, 0xF3, 0xF2, 0x32, 0x36, 0xF6, 0xF7,
  0x37, 0xF5, 0x35, 0x34, 0xF4, 0x3C, 0xFC, 0xFD, 0x3D, 0xFF, 0x3F, 0x3E, 0xFE, 0xFA, 0x3A,
  0x3B, 0xFB, 0x39, 0xF9, 0xF8, 0x38, 0x28, 0xE8, 0xE9, 0x29, 0xEB, 0x2B, 0x2A, 0xEA, 0xEE,
  0x2E, 0x2F, 0xEF, 0x2D, 0xED, 0xEC, 0x2C, 0xE4, 0x24, 0x25, 0xE5, 0x27, 0xE7, 0xE6, 0x26,
  0x22, 0xE2, 0xE3, 0x23, 0xE1, 0x21, 0x20, 0xE0, 0xA0, 0x60, 0x61, 0xA1, 0x63, 0xA3, 0xA2,
  0x62, 0x66, 0xA6, 0xA7, 0x67, 0xA5, 0x65, 0x64, 0xA4, 0x6C, 0xAC, 0xAD, 0x6D, 0xAF, 0x6F,
  0x6E, 0xAE, 0xAA, 0x6A, 0x6B, 0xAB, 0x69, 0xA9, 0xA8, 0x68, 0x78, 0xB8, 0xB9, 0x79, 0xBB,
  0x7B, 0x7A, 0xBA, 0xBE, 0x7E, 0x7F, 0xBF, 0x7D, 0xBD, 0xBC, 0x7C, 0xB4, 0x74, 0x75, 0xB5,
  0x77, 0xB7, 0xB6, 0x76, 0x72, 0xB2, 0xB3, 0x73, 0xB1, 0x71, 0x70, 0xB0, 0x50, 0x90, 0x91,
  0x51, 0x93, 0x53, 0x52, 0x92, 0x96, 0x56, 0x57, 0x97, 0x55, 0x95, 0x94, 0x54, 0x9C, 0x5C,
  0x5D, 0x9D, 0x5F, 0x9F, 0x9E, 0x5E, 0x5A, 0x9A, 0x9B, 0x5B, 0x99, 0x59, 0x58, 0x98, 0x88,
  0x48, 0x49, 0x89, 0x4B, 0x8B, 0x8A, 0x4A, 0x4E, 0x8E, 0x8F, 0x4F, 0x8D, 0x4D, 0x4C, 0x8C,
  0x44, 0x84, 0x85, 0x45, 0x87, 0x47, 0x46, 0x86, 0x82, 0x42, 0x43, 0x83, 0x41, 0x81, 0x80,
  0x40
};

TOF050FSensor::TOF050FSensor() {

    tofSerial = new HardwareSerial(0);
}

TOF050FSensor::~TOF050FSensor() {
    if (tofSerial) {
        delete tofSerial;
    }
}

bool TOF050FSensor::begin() {
    Serial.println("TOF050F传感器开始初始化...");
    Serial.printf("使用引脚: RX=%d, TX=%d, 波特率=%d\n", TOF050F_RX_PIN, TOF050F_TX_PIN, TOF050F_BAUD_RATE);

    tofSerial->begin(TOF050F_BAUD_RATE, SERIAL_8N1, TOF050F_RX_PIN, TOF050F_TX_PIN);

    while (tofSerial->available()) {
        tofSerial->read();
    }

    rxRdIndex = 0;
    rxWrIndex = 0;
    lastRxTimestamp = 0;
    timCount = 0;
    lastDistance = -1;
    sensorValid = false;
    newDataAvailable = false;

    Serial.println("TOF050F传感器初始化完成");

    delay(100);
    return true;
}

int16_t TOF050FSensor::readDistance() {
    uint8_t testBuff[20];

    testBuff[0] = 0;
    testBuff[1] = 3;
    testBuff[2] = REG_RD_ADDR >> 8;
    testBuff[3] = REG_RD_ADDR;
    testBuff[4] = 0;
    testBuff[5] = 1;

    uart_tpm_tx_data(0, testBuff, 6);

    delay(50);
    update();

    return lastDistance;
}

void TOF050FSensor::setContinuousOutput(uint16_t interval_ms) {
    uint8_t testBuff[20];

    testBuff[0] = 0;
    testBuff[1] = 6;
    testBuff[2] = REG_WR_ADDR >> 8;
    testBuff[3] = REG_WR_ADDR;
    testBuff[4] = interval_ms >> 8;
    testBuff[5] = interval_ms;

    uart_tpm_tx_data(0, testBuff, 6);
}

void TOF050FSensor::stopContinuousOutput() {
    setContinuousOutput(0);
}

void TOF050FSensor::update() {
    uart_tpm_main();
}

bool TOF050FSensor::hasNewData() {
    return newDataAvailable;
}

int16_t TOF050FSensor::getLastDistance() {
    newDataAvailable = false;
    return lastDistance;
}

bool TOF050FSensor::isValid() {
    return sensorValid;
}

uint16_t TOF050FSensor::crc16_calculate_modbus(uint8_t *p_data, uint16_t len) {
    uint8_t crchi = 0xff;
    uint8_t crclo = 0xff;
    uint16_t index;
    while (len--) {
        index = crclo ^ *p_data++;
        crclo = crchi ^ crc16mTableHi[index];
        crchi = crc16mTableLo[index];
    }
    return (crchi << 8 | crclo);
}

uint16_t TOF050FSensor::uart_read_isr(uint8_t channel, uint8_t *p_buff) {
    uint16_t i = 0, wrIndex = 0;
    for (wrIndex = rxWrIndex; wrIndex != rxRdIndex; rxRdIndex = (rxRdIndex + 1) % 80, i++) {
        p_buff[i] = rxBuffer[rxRdIndex];
    }
    return i;
}

uint8_t TOF050FSensor::uart_tpm_rx_isr(uint8_t channel, uint8_t data) {
    if (rxRdIndex == ((rxWrIndex + 1) % 80)) {
        return 1;
    } else {
        rxBuffer[rxWrIndex] = data;
        rxWrIndex = (rxWrIndex + 1) % 80;
    }
    lastRxTimestamp = tim_get_count();
    return 0;
}

void TOF050FSensor::uart_tpm_main(void) {
    uint16_t rxLen = 0;
    uint16_t crc16 = 0;
    uint8_t tempBuff[80];

    while (tofSerial->available()) {
        uint8_t data = tofSerial->read();
        uart_tpm_rx_isr(0, data);
    }

    if (tim_check_timeout(lastRxTimestamp, tim_get_count(), frameTimeInvt)) {
        rxLen = uart_read_isr(0, tempBuff);
        if (rxLen > 2) {
            crc16 = tempBuff[rxLen - 1];
            crc16 <<= 8;
            crc16 |= tempBuff[rxLen - 2];
            if (crc16 == crc16_calculate_modbus(tempBuff, rxLen - 2)) {
                modbus_recv_data(tempBuff, rxLen - 2);
            }
        }
        lastRxTimestamp = tim_get_count();
    }
}

uint8_t TOF050FSensor::uart_tpm_tx_data(uint8_t channel, uint8_t *p_data, uint16_t len) {
    uint16_t crc16 = 0;
    if (NULL == p_data || 0 == len || len + 2 > 80) {
        return 1;
    }
    memcpy(txBuffer, p_data, len);
    crc16 = crc16_calculate_modbus(txBuffer, len);
    txBuffer[len] = crc16;
    txBuffer[len + 1] = crc16 >> 8;
    tofSerial->write(txBuffer, len + 2);
    return 1;
}

void TOF050FSensor::modbus_recv_data(uint8_t *p_data, uint16_t len) {

    if (len >= 5 && p_data[1] == 3) {
        uint16_t distance = p_data[3];
        distance <<= 8;
        distance |= p_data[4];

        if (distance != 0xFFFF) {
            lastDistance = distance;
            sensorValid = true;
            newDataAvailable = true;

        } else {
            sensorValid = false;

        }
    } else {
        Serial.println("TOF050F数据格式不正确");
    }
}

uint32_t TOF050FSensor::tim_get_count(void) {
    return millis() / 2;
}

uint8_t TOF050FSensor::tim_check_timeout(uint32_t start, uint32_t now, uint32_t invt) {
    if ((uint32_t)(start + invt) >= start) {
        if ((now >= (uint32_t)(start + invt)) || (now < start)) {
            return 1;
        }
    } else {
        if ((now < start) && (now >= (uint32_t)(start + invt))) {
            return 1;
        }
    }
    return 0;
}
